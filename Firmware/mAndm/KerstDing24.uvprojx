# Keil uVision project KerstDing24.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: KerstDing23
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: ad.c buttons.c leds.c main.c pwm.c usart2.c ir.c
  group Headers
    ./: ad.h buttons.h leds.h pwm.h usart2.h ir.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
