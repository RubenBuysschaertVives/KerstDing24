# Keil uVision project KerstDing24.uvprojx, settings and files
target Nucleo-F091RC (6220000::V6.22::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ./: main.c usart2.c dac.c lissajous.c ad.c buttons.c ir.c leds.c pwm.c
  group Headers
    ./: usart2.h dac.h lissajous.h ad.h buttons.h ir.h leds.h pwm.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
